# Keil uVision project demo.uvprojx, settings and files
target ShopCart (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --gnu
  c include: ..\..\..\lib\math;..\..\..\lib\onchip\ADC;..\..\..\lib\onchip\capture;..\..\..\lib\onchip\delay;..\..\..\lib\onchip\flash;..\..\..\lib\onchip\GPIO;..\..\..\lib\onchip\I2C;..\..\..\lib\onchip\interrupt;..\..\..\lib\onchip\PWM;..\..\..\lib\onchip\taskManager;..\..\..\lib\onchip\timer;..\..\..\lib\onchip\USART;..\..\..\lib\offchip\LED;.\app;..\..\..\lib\offchip\esp8266;..\..\..\lib\onchip\SPI;..\..\..\lib\offchip\MFRC522
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib/onchip
    ../../../lib/onchip/GPIO/: GPIO.cpp
    ../../../lib/onchip/interrupt/: Interrupt.cpp
    ../../../lib/onchip/taskManager/: TaskManager.cpp
    ../../../lib/onchip/USART/: USART.cpp
    ../../../lib/onchip/SPI/: SPI.cpp
  group lib/offchip
    ../../../lib/offchip/LED/: LED.cpp
    ../../../lib/offchip/esp8266/: esp8266.cpp Socket_esp8266.cpp
    ../../../lib/offchip/MFRC522/: MFRC522.cpp
  group app
    ./app/: Main.cpp Configuration.h UserInterrupt.cpp Communicate.cpp
  group math
    ../../../lib/math/: MD5.cpp
software components: CMSIS:CORE 4.3.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
