# Keil uVision project EP-Guide.uvprojx, settings and files
target EP-Guide (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EP-Guide +hex
  c flags: wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\Libraries\BSP\USART;..\..\Libraries\Math;..\..\System;..\..\Libraries\BSP\RFID;..\..\Libraries\BSP\GPIO;..\..\App;..\..\System\TaskManager;..\..\Libraries\BSP\SPI
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BSP
    ../../Libraries/BSP/USART/: USART.cpp
    ../../Libraries/BSP/RFID/: MFRC522.cpp
    ../../Libraries/BSP/GPIO/: GPIO.cpp
  group System
    ../../System/: main.cpp Interrupt.cpp
    ../../System/TaskManager/: TaskManager.cpp
  group App
    ../../App/: App.cpp
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.1.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c
    RTE/Device/STM32F103C8/: RTE_Device.h startup_stm32f10x_md.s stm32f10x_conf.h system_stm32f10x.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
